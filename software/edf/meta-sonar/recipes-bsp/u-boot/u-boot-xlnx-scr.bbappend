FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:ultrazed-3eg-iocc = " file://boot.cmd.ultrazed-iocc"
