FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:cora-z7-10 = " file://cora-hardware.cfg"
