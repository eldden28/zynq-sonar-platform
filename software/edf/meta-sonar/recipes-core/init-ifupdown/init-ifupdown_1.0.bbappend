# Keep the Cora direct-cable address when migrating from PetaLinux.
FILESEXTRAPATHS:prepend:cora-z7-10 := "${THISDIR}/files:"
