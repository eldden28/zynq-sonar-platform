# Override EDF's more-specific hostname setting for this physical board.
hostname:pn-base-files:amd-edf:ultrazed-3eg-iocc = "ultrazed-3eg-iocc"
