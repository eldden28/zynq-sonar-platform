options:
  parameters:
    description: PC control and observation graph for Cora Remote I/O v1.
    generate_options: qt_gui
    id: cora_remote_io_pc
    output_language: python
    title: Cora Remote I/O - PC
  states: {}

blocks:
- name: board_ip
  id: variable
  parameters:
    value: '"192.168.10.2"'
  states: {}
- name: adc_samp_rate
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: pwm_samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: pwm_level
  id: variable_qtgui_range
  parameters:
    label: PWM level (-1 = 0%, 0 = 50%, +1 = 100%)
    min_len: '300'
    orient: Qt.Horizontal
    start: '-1.0'
    step: '0.01'
    stop: '1.0'
    value: '0.0'
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: board_ip
    comment: 'A0 samples from Cora: normalized float32 at adc_samp_rate.'
    port: '50000'
    server: 'False'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 'A0 normalized voltage: -1 = 0 V, +1 = 3.3 V.'
    grid: 'True'
    label1: A0_normalized
    name: '"Cora A0 (XADC)"'
    srate: adc_samp_rate
    type: float
    ylabel: Normalized_A0
    ymax: '1.0'
    ymin: '-1.0'
    size: '1000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    comment: Continuously produces the slider value for board PWM.
    const: pwm_level
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Match Cora Remote I/O PWM stream rate.
    samples_per_second: pwm_samp_rate
    type: float
  states: {}
- name: cora_tcp_float_sink_0
  id: cora_tcp_float_sink
  parameters:
    comment: PWM command stream to the Cora board.
    host: board_ip
    port: '50001'
  states: {}

connections:
- [network_tcp_source_0, '0', qtgui_time_sink_x_0, '0']
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', cora_tcp_float_sink_0, '0']

metadata:
  file_format: 1
